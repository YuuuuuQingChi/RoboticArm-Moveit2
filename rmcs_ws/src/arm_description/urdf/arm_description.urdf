Commit message: update

File: rmcs_ws/src/arm_description/urdf/arm_description.urdf (robot description, URDF)
Before this commit: robot arm_description, 7 links, 6 joints
Joints:
- joint joint_1: limit lower=-3.1 upper=3.1 effort=25 velocity=7.75 -> lower=-2.8 upper=2.8 effort=25 velocity=7.75
